# IAR project Exp6.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: S3C2410A Samsung S3C2410A
  ICCARM.CCIncludePath2: inc; src; inc\drv; inc\sys; src\GUI; src\Pic; src\user; ucos-ii; ucos-ii\ADD; ucos-ii\arch; ucos-ii\uhal
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Exp10.bin
  ILINK.IlinkOutputFile: Exp6.out
  ILINK.IlinkIcfFile: s3c2410_ram.icf
  ILINK.IlinkExtraOptions: raw-binary
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group init
    init/: exception.s retarget.c
  group src
    src/: app.c app.h app_cfg.h enemy.c enemy.h includes.h main.c myplane.c myplane.h
  group src/Drv
    src/drv/: cpu.c drivers.c LCD320.c lcd320.h LED.c LED.h serial-2410.c
    src/sys/: lib.c Uart.c
  group src/Pic
    src/Pic/: BackGround.c BeatPlane_Text.c BigFoe1.c BigFoe2.c BigFoeD.c Button_BK.c Button_ST.c EndPic.c MiddleFoe1.c MiddleFoe2.c MiddleFoeD.c MyPlane1.c MyPlane2.c MyPlaneD.c Number.c Pic.h Plane_BK1.c Plane_BK2.c Plane_BK3.c Score_Text.c Score_Text1.c Shot.c SmallFoe.c SmallFoeD.c
  group startup
    startup/: Startup.s
  group ucos-ii/ADD
    ucos-ii/ADD/: OSAddTask.c
  group ucos-ii/arch
    ucos-ii/arch/: os_cpu_a.s os_cpu_c.c
  group ucos-ii/kernel
    ucos-ii/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group ucos-ii/uhal
    ucos-ii/uhal/: isr.c uhal.c
